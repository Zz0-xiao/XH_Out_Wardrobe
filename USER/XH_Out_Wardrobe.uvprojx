# Keil uVision project XH_Out_Wardrobe.uvprojx, settings and files
target XH_Out_Wardrobe (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F030R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: XH_Out_Wardrobe +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F030,USE_DEFAULT_TIMEOUT_CALLBACK
  c include: ..\USER;..\CORE;..\STM32F03x_FWLib\inc;..\HARDWARE;..\OTHER;..\HARDWARE\motor;..\HARDWARE\sensor;..\HARDWARE\timer;..\HARDWARE\rs232;..\HARDWARE\rs485;..\HARDWARE\communication
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group USER
    ./: main.c stm32f0xx_it.c system_stm32f0xx.c
  group HARDWARE
    ../HARDWARE/motor/: motor.c
    ../HARDWARE/sensor/: sensor.c
    ../HARDWARE/timer/: timer.c
    ../HARDWARE/communication/: communication.c
    ../HARDWARE/rs232/: rs232.c
    ../HARDWARE/rs485/: rs3485.c
  group CORE
    ../CORE/: startup_stm32f030.s
  group FWLIB
    ../STM32F03x_FWLib/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_misc.c stm32f0xx_iwdg.c stm32f0xx_pwr.c stm32f0xx_tim.c stm32f0xx_usart.c
  group OTHER
    ../OTHER/: delay.c utility.c
  group README
    ../: README.md
